// symbols.cpp
#include "symbols.h"
#include <string.h>

// 設定で選べるシンボル (名前は日本語。画面では L() で英語にもする)。icon は SYMBOL_ICONS の番号 (1から)
const SymbolChoice SYMBOL_CHOICES[SYMBOL_CHOICE_COUNT] = {
  { "車", '/', '>', 1, 9 },
  { "トラック", '/', 'k', 2, 14 },
  { "大型トラック", '/', 'u', 3, 14 },
  { "バン", '/', 'v', 4, 9 },
  { "ジープ", '/', 'j', 5, 9 },
  { "キャンピングカー", '/', 'R', 6, 8 },
  { "バス", '/', 'U', 7, 9 },
  { "オートバイ", '/', '<', 8, 9 },
  { "自転車", '/', 'b', 9, 7 },
  { "徒歩・ハンディ", '/', '[', 10, 7 },
  { "船 (動力船)", '/', 's', 11, 8 },
  { "ヨット", '/', 'Y', 12, 8 },
  { "小型機", '/', '\'', 13, 11 },
  { "ヘリコプター", '/', 'X', 14, 11 },
  { "気球", '/', 'O', 15, 11 },
  { "自宅", '/', '-', 16, 0 },
  { "自宅 (八木)", '/', 'y', 17, 0 },
  { "テント (移動運用)", '/', ';', 18, 12 },
  { "ノートPC", '/', 'l', 19, 12 },
  { "気象局", '/', '_', 20, 13 },
  { "デジピーター", '/', '#', 21, 0 },
};

// 16x16 の絵。1行2バイト (左のドットが上位ビット)、16行。M5APRS用に描いたもの
static const uint8_t ICONS[SYMBOL_ICON_COUNT][32] = {
  { 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x19, 0x30, 0x31, 0x18, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0x87, 0x2C, 0x34, 0x1E, 0x78, 0x1E, 0x78, 0x0C, 0x30, 0x00, 0x00 },   // 1 /> Car
  { 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x4C, 0x00, 0x46, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0x87, 0x2C, 0x34, 0x1E, 0x78, 0x1E, 0x78, 0x0C, 0x30, 0x00, 0x00 },   // 2 /k Truck
  { 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xEE, 0xFF, 0xEB, 0xFF, 0xE9, 0xFF, 0xEF, 0xFF, 0xEF, 0xFF, 0xFF, 0x77, 0x1C, 0x77, 0x1C, 0x22, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },   // 3 /u Semi
  { 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x49, 0x18, 0x49, 0x0C, 0x49, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0x87, 0x2C, 0x34, 0x1E, 0x78, 0x1E, 0x78, 0x0C, 0x30, 0x00, 0x00 },   // 4 /v Van
  { 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x40, 0x10, 0x60, 0x10, 0x50, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0x87, 0x2C, 0x34, 0x1E, 0x78, 0x1E, 0x78, 0x0C, 0x30, 0x00, 0x00 },   // 5 /j Jeep
  { 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x4C, 0xF0, 0x4C, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0x87, 0x2C, 0x34, 0x1E, 0x78, 0x1E, 0x78, 0x0C, 0x30, 0x00, 0x00 },   // 6 /R RV
  { 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x92, 0x4A, 0x92, 0x49, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0x87, 0x2C, 0x34, 0x1E, 0x78, 0x1E, 0x78, 0x0C, 0x30, 0x00, 0x00 },   // 7 /U Bus
  { 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x10, 0x00, 0x10, 0x1C, 0xF0, 0x1F, 0xF0, 0x1F, 0xE8, 0x77, 0xCE, 0xA8, 0x15, 0xA8, 0x15, 0x88, 0x11, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x00 },   // 8 /< Motorcycle
  { 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0E, 0x20, 0x07, 0xE0, 0x0C, 0x60, 0x0A, 0x50, 0x72, 0x9C, 0x99, 0xAA, 0xBF, 0x2A, 0x88, 0x22, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x00 },   // 9 /b Bicycle
  { 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x07, 0xE0, 0x0F, 0xF0, 0x1B, 0xD8, 0x13, 0xC8, 0x03, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x18, 0x18, 0x18, 0x00, 0x00 },   // 10 /[ Person
  { 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0A, 0xA0, 0x1F, 0xF0, 0xFF, 0xFF, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x63, 0x18, 0x94, 0xA5, 0x00, 0x00 },   // 11 /s Ship
  { 0x01, 0x00, 0x03, 0x00, 0x03, 0x40, 0x05, 0x60, 0x07, 0x60, 0x0F, 0x30, 0x1D, 0x30, 0x1B, 0x30, 0x37, 0x60, 0x2D, 0x40, 0x7F, 0x40, 0x7F, 0xFE, 0x3F, 0xFC, 0x00, 0x00, 0x99, 0x99, 0x66, 0x66 },   // 12 /Y Yacht
  { 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },   // 13 /' Small plane
  { 0x00, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x0F, 0xC0, 0x19, 0xC0, 0x31, 0xFF, 0x3F, 0xE3, 0x1F, 0xC0, 0x08, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },   // 14 /X Helicopter
  { 0x07, 0xE0, 0x1B, 0xD8, 0x3B, 0xDC, 0x7B, 0xDE, 0x7B, 0xDE, 0x7B, 0xDE, 0x3B, 0xDC, 0x1B, 0xD8, 0x0B, 0xD0, 0x07, 0xE0, 0x02, 0x40, 0x02, 0x40, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00 },   // 15 /O Balloon
  { 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x30, 0x0C, 0x36, 0x6C, 0x36, 0x6C, 0x30, 0x6C, 0x30, 0x6C, 0x30, 0x6C, 0x3F, 0xFC, 0x00, 0x00 },   // 16 /- Home
  { 0x2A, 0x80, 0x7F, 0xC0, 0x2A, 0x80, 0x04, 0x00, 0x04, 0x00, 0x05, 0x80, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x30, 0x0C, 0x36, 0x6C, 0x36, 0x6C, 0x30, 0x6C, 0x30, 0x6C, 0x3F, 0xFC },   // 17 /y Home Yagi
  { 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x7E, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00 },   // 18 /; Camp
  { 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x3F, 0xFC, 0x7F, 0xFE, 0x55, 0x54, 0xFF, 0xFF, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },   // 19 /l Laptop
  { 0x00, 0x00, 0x08, 0x00, 0x49, 0x00, 0x3E, 0x00, 0x32, 0xF0, 0xE9, 0xF8, 0x27, 0xFC, 0x5F, 0xFC, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x00, 0x00, 0x22, 0x22, 0x44, 0x44, 0x00, 0x00 },   // 20 /_ WX
  { 0x00, 0x00, 0x21, 0x84, 0x49, 0x92, 0x51, 0x8A, 0x49, 0x92, 0x21, 0x84, 0x01, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x05, 0xA0, 0x0D, 0xB0, 0x0A, 0x50, 0x18, 0x18, 0x10, 0x08, 0x00, 0x00 },   // 21 /# Digi
  { 0x07, 0xE0, 0x18, 0x98, 0x28, 0x7C, 0x50, 0x7E, 0x50, 0xFA, 0x93, 0x21, 0xBC, 0x21, 0xB8, 0x21, 0xF8, 0x71, 0x88, 0x73, 0x88, 0x7D, 0x47, 0x72, 0x7F, 0xA2, 0x27, 0x24, 0x19, 0x58, 0x07, 0xE0 },   // 22 I& iGate
};
static const uint8_t COLORS[SYMBOL_ICON_COUNT] = {
  SYM_COL_WHITE,
  SYM_COL_WHITE,
  SYM_COL_WHITE,
  SYM_COL_WHITE,
  SYM_COL_WHITE,
  SYM_COL_WHITE,
  SYM_COL_WHITE,
  SYM_COL_WHITE,
  SYM_COL_WHITE,
  SYM_COL_WHITE,
  SYM_COL_WHITE,
  SYM_COL_WHITE,
  SYM_COL_WHITE,
  SYM_COL_WHITE,
  SYM_COL_WHITE,
  SYM_COL_CYAN,
  SYM_COL_CYAN,
  SYM_COL_WHITE,
  SYM_COL_WHITE,
  SYM_COL_YELLOW,
  SYM_COL_GREEN,
  SYM_COL_GREEN
};

// SSIDの用途 (APRSでよく使われる割り当て)
// 1〜4・15 は APRS の推奨 (WB4APR の SSIDs.txt) では「汎用」。括弧の中は日本の慣例 (1・2・3 はデジピーター、4・15 は実験局)
static const char* const SSID_USE[16] = {
  "SSIDなし (固定局)", "汎用 (低地デジ)", "汎用 (9k6デジ)", "汎用 (広域デジ)", "汎用 (実験用)", "他のネットワーク", "特別運用・衛星", "ハンディ機",
  "船・キャンピングカー", "モービル", "インターネット・iGate", "気球・航空機", "一方向のトラッカー", "気象局", "トラック (運送)", "汎用 (実験用)" };

int symbol_find(char table, char code) {
  for (int i = 0; i < SYMBOL_CHOICE_COUNT; i++) if (SYMBOL_CHOICES[i].table == table && SYMBOL_CHOICES[i].code == code) return i;
  return -1;
}

static bool overlay_char(char c) { return (c >= '0' && c <= '9') || (c >= 'A' && c <= 'Z'); }

int symbol_icon(char table, char code) {
  if (table == '/') { int i = symbol_find(table, code); return i < 0 ? 0 : SYMBOL_CHOICES[i].icon; }
  if (table == '\\' || overlay_char(table)) {          // 代替表 (オーバーレイ付きを含む)
    if (code == '&') return SYMBOL_ICON_IGATE;          // iGate (I& R& T& など)
    if (code == '#') return SYMBOL_ICON_DIGI;                       // デジピーター (1# I# W# など)
    // 意味の近いプライマリ表のアイコンを当てる (代替表には意味の違う記号も多いので、決まったものだけ)
    char pc = 0;
    switch (code) {
      case '>': pc = '>'; break;                    // 車 (上から見た形。S> H> P> B> など)
      case 'v': pc = 'v'; break;                    // バン
      case 'k': pc = 'j'; break;                    // SUV → ジープ
      case 'u': pc = 'u'; break;                    // トラック (Tu タンクローリー など) → 大型トラック
      case 's': pc = (table == 'Y') ? 'Y' : 's'; break;   // 船 (上から見た形)。Ys はヨット
      case '^': pc = '\''; break;                  // 航空機 (上から見た形) → 小型機
      case '-': pc = '-'; break;                    // 家 (S- 太陽光 W- 風力 など)
    }
    if (pc) { int i = symbol_find('/', pc); return i < 0 ? 0 : SYMBOL_CHOICES[i].icon; }
  }
  return 0;
}

const uint8_t* symbol_icon_bitmap(int icon) { return (icon >= 1 && icon <= SYMBOL_ICON_COUNT) ? ICONS[icon - 1] : NULL; }
uint8_t symbol_icon_color(int icon) { return (icon >= 1 && icon <= SYMBOL_ICON_COUNT) ? COLORS[icon - 1] : (uint8_t)SYM_COL_WHITE; }
const char* ssid_use(uint8_t ssid) { return SSID_USE[ssid & 15]; }
